## boards/shields/nice_view_gem_sharp/Kconfig.shield
```kconfig
config SHIELD_NICE_VIEW_GEM_SHARP
    def_bool $(shields_list_contains,nice_view_gem_sharp)
```
